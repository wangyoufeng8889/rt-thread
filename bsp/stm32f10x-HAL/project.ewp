# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xE; MQTT_COMM_ENABLED; MQTT_DIRECT; IOTX_WITHOUT_TLS; IOTX_NET_INIT_WITH_PK_EXT; _PLATFORM_IS_RTTHREAD_; IOTX_WITHOUT_ITLS; RT_USING_DLIBC; _DLIB_FILE_DESCRIPTOR; _DLIB_THREAD_SUPPORT
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\components\net\sal_socket\include\socket; ..\..\components\libc\compilers\dlib; packages\ali-iotkit-latest\iotkit-embedded\src\log\LITE-log; packages\ali-iotkit-latest\iotkit-embedded\src\system\iotkit-system; ..\..\components\net\sal_socket\include; ..\..\include; ..\..\components\net\sal_socket\include\dfs_net; packages\ali-iotkit-latest\iotkit-embedded\src\sdk-impl; ..\..\libcpu\arm\common; ..\..\components\drivers\include; packages\ali-iotkit-latest\iotkit-embedded\src\sdk-impl\exports; ..\..\components\dfs\filesystems\devfs; ..\..\components\net\at\at_socket; packages\ali-iotkit-latest\iotkit-embedded\src\packages\iot-coap-c; ..\..\components\net\at\include; drivers; packages\ali-iotkit-latest\iotkit-embedded\src\utils\misc; Libraries\STM32F1xx_HAL_Driver\Inc; ..\..\components\net\sal_socket\include\dfs_net\sys_select; .; Libraries\CMSIS\Device\ST\STM32F1xx\Include; ..\..\components\dfs\include; ..\..\libcpu\arm\cortex-m3; ..\..\components\net\sal_socket\include\socket\sys_socket; Libraries\CMSIS\Include; packages\ali-iotkit-latest\iotkit-embedded\src\packages\LITE-utils; ..\..\components\drivers\spi; packages\ali-iotkit-latest\iotkit-embedded\src\mqtt\Link-MQTT\MQTTPacket; applications; packages\ali-iotkit-latest\iotkit-embedded\src\sdk-impl\imports; packages\at_device-latest; ..\..\components\finsh; ..\..\components\dfs\filesystems\elmfat; packages\ali-iotkit-latest\iotkit-embedded\src\utils\digest; packages\ali-iotkit-latest\iotkit-embedded\src\mqtt\Link-MQTT
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; USE_HAL_DRIVER; STM32F103xE; MQTT_COMM_ENABLED; MQTT_DIRECT; IOTX_WITHOUT_TLS; IOTX_NET_INIT_WITH_PK_EXT; _PLATFORM_IS_RTTHREAD_; IOTX_WITHOUT_ITLS; RT_USING_DLIBC; _DLIB_FILE_DESCRIPTOR; _DLIB_THREAD_SUPPORT
  ICCARM.CCOptLevel: 3
  group ali-iotkit
    packages/ali-iotkit-latest/iotkit-embedded/src/system/iotkit-system/src/: ca.c class_interface.c guider.c id2_guider.c iotx_device.c report.c sdk-impl.c
    packages/ali-iotkit-latest/iotkit-embedded/src/packages/iot-coap-c/: CoAPDeserialize.c CoAPExport.c CoAPMessage.c CoAPNetwork.c CoAPSerialize.c
    packages/ali-iotkit-latest/ports/rtthread/: HAL_OS_rtthread.c HAL_TCP_rtthread.c HAL_UDP_rtthread.c
    packages/ali-iotkit-latest/iotkit-embedded/src/coap/: iotx_ca_cert.c iotx_coap_api.c
    packages/ali-iotkit-latest/iotkit-embedded/src/packages/LITE-utils/: json_parser.c json_token.c lite-utils_testsuites.c mem_stats.c string_utils.c
    packages/ali-iotkit-latest/iotkit-embedded/src/log/LITE-log/: lite-log.c
    packages/ali-iotkit-latest/iotkit-embedded/src/mqtt/Link-MQTT/: mqtt_client.c mqtt_instance.c
    packages/ali-iotkit-latest/iotkit-embedded/src/mqtt/Link-MQTT/MQTTPacket/: MQTTConnectClient.c MQTTDeserializePublish.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c
    packages/ali-iotkit-latest/iotkit-embedded/src/utils/digest/: utils_base64.c utils_hmac.c utils_md5.c utils_sha1.c utils_sha256.c
    packages/ali-iotkit-latest/iotkit-embedded/src/utils/misc/: utils_epoch_time.c utils_httpc.c utils_list.c utils_net.c utils_timer.c
  group Applications
    applications/: app_air800.c app_air800_urc.c app_bms.c app_led.c app_main.c main.c
  group AT
    ../../components/net/at/src/: at_cli.c at_client.c at_utils.c
    ../../components/net/at/at_socket/: at_socket.c
  group at_device
    packages/at_device-latest/: at_socket_air800.c
  group CORTEX-M3
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/cortex-m3/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/hwtimer/: hwtimer.c
    ../../components/drivers/mtd/: mtd_nor.c
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/rtc/: rtc.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c spi_flash_w25qxx.c
  group dlib
    ../../components/libc/compilers/dlib/: environ.c libc.c rmtx.c stdio.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c time.c
  group Drivers
    drivers/: board.c drv_gpio.c drv_spi.c drv_usart.c stm32f1xx_it.c
  group Filesystem
    ../../components/dfs/filesystems/elmfat/option/: ccsbcs.c
    ../../components/dfs/filesystems/devfs/: devfs.c
    ../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group finsh
    ../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c msh_file.c shell.c symbol.c
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group SAL
    ../../components/net/sal_socket/impl/: af_inet_at.c
    ../../components/net/sal_socket/dfs_net/: dfs_net.c
    ../../components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    ../../components/net/sal_socket/src/: sal_ipaddr.c sal_socket.c
  group STM32_HAL
    Libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/iar/: startup_stm32f103xe.s
    Libraries/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_mmc.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_adc.c stm32f1xx_ll_crc.c stm32f1xx_ll_dac.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_gpio.c stm32f1xx_ll_i2c.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rcc.c stm32f1xx_ll_rtc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_spi.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c stm32f1xx_ll_usb.c stm32f1xx_ll_utils.c
    Libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
